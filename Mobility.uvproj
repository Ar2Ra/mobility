# Keil uVision project Mobility.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Mobility
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Communcations
    ./: Spi.c Uart0.c
  group Source Code
    ./: Main.c Pwm.c Hall.c Commands.c Adc.c
  group Tasks
    ./: Task_list.c Task_mech.c
  group Documentation
    ./: README.md Int_Priority.txt
target LPC2148 Flash (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: as above
  output: Mobility +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
target LPC2148 RAM (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: as above
  output: Mobility +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x40000000 size 0x4000
  memory RVCT9: RAM 0x40004000 size 0x4000
